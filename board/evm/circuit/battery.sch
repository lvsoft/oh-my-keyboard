File: board/evm/circuit/battery.sch (KiCad schematic (older format))
At the start: 75 parts

Commit message: working on qc3
Parts:
- gave numbers to parts that had none: 75
