File: board/evm/circuit/usb_dongle.sch (KiCad schematic (older format))
At the start: 24 parts

Commit message: working on qc3
Parts:
- gave numbers to parts that had none: 24
